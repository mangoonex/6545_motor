# Keil uVision project 6545.uvproj, settings and files
target CE43 Example (MCS-51)
  device: 71M6543 Teridian Semiconductor Corp.
  cpu: IRAM(0-0xFF) XRAM(0-0x13FF) IROM(0-0xFFFF) CLOCK(5000000)  MODC2
  output: ce43_ex.abs +hex
  c flags: Optimize=9
  c include: .\
  group Main
    ./source/: m654x.c main.c eeprom.c energy.c
  group CE
    ./source/: ce43a02_ce.c ce43a02_dat.c
